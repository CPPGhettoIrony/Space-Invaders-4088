# Keil uVision project Proyecto_final.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Proyecto_final
  c flags: Optim=1 OneElfS=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c nunchuk.h nunchuk.c sprites.c sprites.h jugador.c jugador.h sonido.c sonido.h
  group Librerias
    ./: lpc40xx_adc.lib lpc40xx_base.lib lpc40xx_i2c.lib lpc40xx_uart.lib
  group Cabeceras h
    ./: adc_lpc40xx.h error.h glcd.h gpio_lpc40xx.h i2c_lpc40xx.h iocon_lpc40xx.h joystick.h leds.h timer_lpc40xx.h uart_lpc40xx.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
